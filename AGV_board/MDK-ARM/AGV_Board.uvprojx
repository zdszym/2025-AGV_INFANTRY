# Keil uVision project AGV_Board.uvprojx, settings and files
target AGV_Board (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF)   CLOCK(25000000) CPUTYPE("Cortex-M3") TZ
  output: AGV_Board +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: USE_HAL_DRIVER,STM32F105xC,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BSP;../APP;../task;../refree
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f105xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Task
    ../User/: task_scheduler.c
    ../task/: SW_control_task.c
  group BSP
    ../BSP/: M3508_bsp.c pack_handler_bsp.c M3508_gear_bsp.c briter_encoder_bsp.c steering_wheel_bsp.c can_bsp.c steering_communication_bsp.c buzzer_bsp.c
  group APP
    ../APP/: M3508.c M3508_gear.c briter_encoder.c pid_regulator.c steering_wheel.c steering_communication.c chassis_power_control.c buzzer.c
  group refree
    ../refree/: algorithmOfCRC.c refree.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2
